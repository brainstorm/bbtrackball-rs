# Repository brainstorm/bbtrackball-rs

File README.md:

# :mouse: Blackberry rusty mouse

The purpose of this project is to build a [blackberry-trackball mouse][bb_trackball] and glue it to the middle of [an (allegedly) ergonomic keyboard][microsoft_natural_keyboard_4000]... **in Rust Embedded**, for the [STM32F042][stm32f042] :)

This came about [from twitter idea to board, then to Rust Embedded](https://twitter.com/braincode/status/1275406584714104833). The code is based on [RTIC][rtic] rust-embedded framework (formerly known as RTFM). It exclusively uses interrupts *and* [also works on OSX, not only Linux][osx_not_working] (wink wink, nudge nudge, [James][jamesmunns] ;P).

## :rocket: Future improvements shall you take this code with you

* DPI tweaking to have a better trackball accuracy or speed/stepping.
* [Button debouncer][debouncer].
* Remove one of the buttons of the <acronym title="Printed Circuit Board">PCB</acronym>, since it conflicts with one of the trackball GPIOs... oops, hardware blopper ;)
* Add acceleration [like @LSChyi did][add_accel]?
* Perhaps a clever (optical) system to make this experiment actually practical and useful :P
* On OSX the mouse works fine. **On GNU/Linux systems, the mouse might stop responding after ~30 seconds of use**. [This could be related to the Linux USB autosuspend subsystem.](https://askubuntu.com/questions/185274/how-can-i-disable-usb-autosuspend-for-a-specific-device). Try to fix that from the firmware so that it works everywhere?
* If enough people show interest and [**choose to sponsor me**][gh_sponsor_1], I would love to look at how to:
	1. Understand the flash process of the [Beken 3231][beken3231].
	2. Implement an LLVM backend for the [ARM968E-S][ARM968E-S] and have `rustc` working with it.
	3. Goal: **have a sub-$1 bluetooth IC that potentially does all we need and more** plus learn to [implement an LLVM backend from scratch][llvm_cpu0]. Also provide [**a way to upcycle bluetooth hardware, keeping it away from the dumpster.**][old_beken_hardware]
* ~~[Write a simplified RTIC example to return the favour to that amazing rust-embedded community][rtic_hid_example]~~: [Done][rtic_pr].

## :clap: Special thanks to

[@joshajohnson][joshajohnson]
[@mvirkkunen][lumpio]
[@therealprof][therealprof]
[@jamesmunns][jamesmunns]
[@TeXitoi][texitoi]
[@TheZoq2][thezoq2]

And all the folks from the [RTIC matrix.org community][rtic_matrix] for patiently guiding and helping me in this experiment.

[bb_trackball]: https://os.mbed.com/users/AdamGreen/notebook/blackberrytrackballmouse/
[joshajohnson]: https://github.com/joshajohnson
[lumpio]: https://github.com/mvirkkunen/
[therealprof]: https://github.com/therealprof/
[rtic]: https://rtic.rs/
[jamesmunns]: https://github.com/jamesmunns
[osx_not_working]: https://github.com/jamesmunns/OtterPill-rs/commit/8e68fbd5bb1161d8131a99d98c90c3e949f49ec1
[rtic_hid_example]: https://github.com/rtic-rs/rtic-examples/issues/10#issuecomment-677464683
[add_accel]: https://github.com/LSChyi/blackberry-mini-trackball
[debouncer]: https://crates.io/crates/unflappable
[microsoft_natural_keyboard_4000]: https://www.microsoft.com/accessories/en-us/products/keyboards/natural-ergonomic-keyboard-4000/b2m-00012
[stm32f042]: https://www.st.com/en/microcontrollers-microprocessors/stm32f0-series.html
[rtic_pr]: https://github.com/rtic-rs/rtic-examples/pull/12
[gh_sponsor_1]: https://github.com/login?return_to=%2Fsponsors%2Fbrainstorm%2Fsponsorships%3Ftier_id%3D27561
[mitxela]: https://mitxela.com/forum/topic/beken-bk3231
[ARM968E-S]: https://static.docs.arm.com/ddi0311/d/DDI0311.pdf
[beken3231]: https://pdfhost.io/v/3r1I3HggE_BK3231_Bluetooth_HID_SoCpdf.pdf
[llvm_cpu0]: http://jonathan2251.github.io/lbd/TutorialLLVMBackendCpu0.pdf
[texitoi]: https://github.com/TeXitoi
[thezoq2]: https://gitlab.com/TheZoq2/hotas
[old_beken_hardware]: https://mitxela.com/forum/topic/mocute-051-bluetooth-gamepad-bk3231-change-hid-profile-from-keyboard-gamepad
[rtic_matrix]: https://matrix.to/#/#rtic:matrix.org

## KiCad design hardware/stm32-trackball/stm32_dev.kicad_pcb

Parts:
C1, C3: 1u; C_0603_1608Metric; MPN CL10A105MP8NNNC; LCSC C15849
C2: 100n; C_0603_1608Metric; MPN CL10B104KB8NNNC; LCSC C14663
C5, C6, C7, C8, C9, C10: 100n; C_0603_1608Metric
D1, D2, D3, D4, D5, D6: LED; LED_0603_1608Metric
F1: 500mA; Fuse_0603_1608Metric
H1, H2, H3: Fuduical; Fiducial_1mm_Mask2mm
H4, H5, H6, H7, H8, H9: M2; MountingHole_2.2mm_M2
H10: Title; board-title
J1: USB_C_Receptacle_USB2.0; USB_C_U262-161N-4BVC11; MPN U262-161N-4BVC11; LCSC C319148
J2: SWD; STM_4_PIN_THT_Staggered
J3: UART; STM_3_PIN_THT_Staggered
J4: SPARE; PinHeader_1x06_P2.54mm_Vertical
J5, J6: Breakout; PinHeader_1x11_P2.54mm_Vertical
R1, R2: 2K2; R_0603_1608Metric
R3, R4, R5, R6, R11, R12, R13, R14: 10K; R_0603_1608Metric
R7, R8, R9, R10: 220R; R_0603_1608Metric
RN1: 5K1; R_Array_Convex_4x0603; MPN CAY16-512J4LF; LCSC C12028
SW1, SW2, SW4, SW5, SW6: KMR2; SW_Push_KMR2; MPN PTS840GMSMTRLFS; LCSC C221909
SW3: SW_Push; Trackball_Tactile_Switch
T1: Trackball; TRACKBALL
U1: AP2112K-3.3; SOT-23-5; MPN AP2112K-3.3TRG1; LCSC C51118
U2: USBLC6-2SC6; SOT-23-6
U3: STM32F042G6Ux; QFN-28_4x4mm_P0.5mm
U4, U5, U6, U7: AN48840B; SOT-353_SC-70-5

Connections:
+3V3: C3.2, C5.2, C6.2, C7.1, C8.1, C9.1, C10.1, D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), J5.1, J6.1, R3.1, R4.1, R5.1, R6.1, R11.1, R12.1, R13.1, R14.1, RN1.1, SW1.2, U1.5 (VOUT), U3.5 (VDDA), U3.17 (VDD), U3.18 (VDDIO2), U4.4 (VCC), U5.4 (VCC), U6.4 (VCC), U7.4 (VCC)
/BOOT0: RN1.7, SW1.1, U3.1 (PB8)
/SPARE_1: J4.1, U3.3 (PF1)
/SPARE_2: J4.2, U3.2 (PF0)
/SPARE_3: J4.3, U3.26 (PB5)
/SPARE_4: J4.4, R12.2, SW4.2, U3.25 (PB4)
/SPARE_5: J4.5, R13.2, SW5.2, U3.24 (PB3)
/SPARE_6: J4.6, R14.2, SW6.2, U3.23 (PA15)
/SWDCLK: J2.4, U3.22 (PA14)
/SWDIO: J2.2, U3.21 (PA13)
/TB_DOWN: J5.7, J6.7, R6.2, U3.13 (PA7), U7.5 (OUT)
/TB_LEFT: J5.4, J6.4, R3.2, U3.10 (PA4), U4.5 (OUT)
/TB_RIGHT: J5.6, J6.6, R4.2, U3.12 (PA6), U5.5 (OUT)
/TB_UP: J5.5, J6.5, R5.2, U3.11 (PA5), U6.5 (OUT)
/UART_RX: J3.1, U3.28 (PB7)
/UART_TX: J3.2, U3.27 (PB6)
/USB+: J1.A6 (D+), J1.B6 (D+), U2.3 (IO2)
/USB-: J1.A7 (D-), J1.B7 (D-), U2.1 (IO1)
/USB_N: U2.6 (IO1), U3.19 (PA9/PA11)
/USB_P: U2.4 (IO2), U3.20 (PA10/PA12)
/USR_LED: D1.2 (A), U3.15 (PB1)
/nLED_BLU: J5.11, J6.11, R7.2, U3.8 (PA2)
/nLED_GRN: J5.9, J6.9, R9.2, U3.7 (PA1)
/nLED_RED: J5.10, J6.10, R8.2, U3.6 (PA0)
/nLED_WHT: J5.8, J6.8, R10.2, U3.9 (PA3)
/nRST: C2.1, J2.1, RN1.8, SW2.2, U3.4 (NRST)
/nTB_BUTTON: J5.3, J6.3, R11.2, SW3.2, U3.14 (PB0)
GND: C1.1, C2.2, C3.1, C5.1, C6.1, C7.2, C8.2, C9.2, C10.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.3, J3.3, J5.2, J6.2, R1.2, R2.2, RN1.2, RN1.3, RN1.4, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, U1.2 (GND), U2.2 (GND), U3.16 (VSSA), U4.2 (GND), U5.2 (GND), U6.2 (GND), U7.2 (GND)
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1
unnamed: D3.1 (K), R7.1
unnamed: D4.1 (K), R8.1
unnamed: D5.1 (K), R9.1
unnamed: D6.1 (K), R10.1
unnamed: F1.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U2.5 (VBUS)
unnamed: J1.A5 (CC1), RN1.5
unnamed: J1.B5 (CC2), RN1.6
VBUS: C1.2, F1.1, U1.1 (VIN), U1.3 (EN)

Notes on the sheet:
USB Type-C Connector
Voltage Regulator
DFU / RESET
Microcontroller
Debug
UART
Blinky / Power
STM32F042 Development
Trackball Breakout
Hall Effect Decoupling
Button LEDs
Breakout Header
Unused Pins
Hall Effect Sensors
Trackball
Mounting Holes
Stopping ERC Errors
Spare Buttons

Board: 2 copper layers, 80.8 x 30.0 mm, 61 parts (1 on the bottom side), 38 nets.

## KiCad design hardware/stm32-trackball-2U/stm32_dev.kicad_pcb

Parts:
C1, C3: 1u; C_0402_1005Metric; MPN CL10A105MP8NNNC; LCSC C15849
C5, C6, C7, C8, C9, C10: 100n; C_0402_1005Metric
C11: 10u; C_0402_1005Metric; MPN CL10A106KP8NNNC; JLCSMT C19702
C12: 4u7; C_0402_1005Metric; MPN CL10A475KO8NNNC; JLCSMT C19666
D2, D3, D4, D5, D6: LED; LED_0603_1608Metric
D7: 1N4148; D_SOD-323; MPN 1N4148W; JLCSMT C81598
F1: 500mA; Fuse_0603_1608Metric
H4, H5, H6, H7: M2; MountingHole_2.2mm_M2
J1: USB_C_Receptacle_USB2.0; USB_C_U262-161N-4BVC11; MPN U262-161N-4BVC11; LCSC C319148
J2: USB; PinHeader_1x04_P1.27mm_Vertical
LOGO1: OSHW Mask; OSHW_Logo_3.6x3.6_F.Mask
LOGO2: Board Details; board-title
Q3: DTC123J; SOT-23
R1, R3: 5K1; R_0402_1005Metric; MPN 0603WAF1501T5E; JLCSMT C22843
R2: 2K2; R_0402_1005Metric
R4, R11, R12: 10K; R_0402_1005Metric
R13: 2K2; R_0402_1005Metric; MPN 0603WAF1501T5E; JLCSMT C22843
R14: 100K; R_0402_1005Metric; MPN 0603WAF1003T5E; JLCSMT C25803
RN1: 10K; R_Array_Convex_4x0402
RN2: 2K2; R_Array_Convex_4x0402
SW1: SW_Push; Panasonic_EVQPUL_EVQPUC
SW2, SW4: BIG; Switch_SMT_SKPMAPE010
SW3: SW_Push; Trackball_Tactile_Switch
T1: Trackball; TRACKBALL
U1: AP2112K-3.3; SOT-23-5; MPN AP2112K-3.3TRG1; LCSC C51118
U2: USBLC6-2SC6; SOT-666
U3: STM32F042G6Ux; QFN-28_4x4mm_P0.5mm
U4, U5, U6, U7: AN48840B; SOT-353_SC-70-5

Connections:
+3V3: C3.2, C5.2, C6.2, C7.1, C8.1, C9.1, C10.1, D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), R4.1, R11.1, R12.1, RN1.5, RN1.6, RN1.7, RN1.8, SW1.1, U1.5 (VOUT), U3.5 (VDDA), U3.17 (VDD), U3.18 (VDDIO2), U4.4 (VCC), U5.4 (VCC), U6.4 (VCC), U7.4 (VCC)
+5V: C1.2, F1.1, U1.1 (VIN), U1.3 (EN)
/BOOT0: C11.1, D7.1 (K), R14.1, U3.1 (PB8)
/BTN_L: R12.2, SW4.2, U3.23 (PA15)
/BTN_R: R4.2, SW2.2, U3.28 (PB7)
/TB_DOWN: RN1.1, U3.13 (PA7), U7.5 (OUT)
/TB_LEFT: RN1.4, U3.10 (PA4), U4.5 (OUT)
/TB_RIGHT: RN1.2, U3.12 (PA6), U5.5 (OUT)
/TB_UP: RN1.3, U3.11 (PA5), U6.5 (OUT)
/USB+: J1.A6 (D+), J1.B6 (D+), J2.3, U2.3 (IO2)
/USB-: J1.A7 (D-), J1.B7 (D-), J2.2, U2.1 (IO1)
/USB_N: U2.6 (IO1), U3.19 (PA9/PA11)
/USB_P: U2.4 (IO2), U3.20 (PA10/PA12)
/nLED_BLU: RN2.4, U3.6 (PA0)
/nLED_GRN: RN2.2, U3.8 (PA2)
/nLED_RED: RN2.3, U3.7 (PA1)
/nLED_WHT: RN2.1, U3.9 (PA3)
/nRST: C12.1, Q3.3 (C), U3.4 (NRST)
/nTB_BUTTON: R11.2, SW3.2, U3.22 (PA14)
GND: C1.1, C3.1, C5.1, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.4, Q3.2 (E), R1.1, R2.2, R3.1, R14.2, SW2.1, SW3.1, SW4.1, U1.2 (GND), U2.2 (GND), U3.16 (VSSA), U4.2 (GND), U5.2 (GND), U6.2 (GND), U7.2 (GND)
unnamed: D2.1 (K), R2.1
unnamed: D3.1 (K), RN2.5
unnamed: D4.1 (K), RN2.6
unnamed: D5.1 (K), RN2.7
unnamed: D6.1 (K), RN2.8
unnamed: D7.2 (A), Q3.1 (B), R13.1
unnamed: J1.A5 (CC1), R1.2
unnamed: J1.B5 (CC2), R3.2
unnamed: R13.2, SW1.2
VBUS: F1.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J2.1, U2.5 (VBUS)

Notes on the sheet:
USB Type-C Connector
Microcontroller
Power
STM32F042
Trackball
Hall Effect Decoupling
Button LEDs
Hall Effect Sensors
Mounting Holes
Stopping ERC Errors
Spare Buttons
DFU / Reset
Voltage Regulator

Board: 2 copper layers, 38.5 x 19.0 mm, 48 parts (28 on the bottom side), 30 nets.

## KiCad design hardware/Sparkfun_Trackballer/kicad/SparkFun_Blackberry_Trackballer_Breakout_v13.kicad_pcb

Parts:
C1, C2, C3, C4: 0.1uF; 0603-CAP
D1: BLU; LED-0603
D2: RED; LED-0603
D3: GRN; LED-0603
D4: WHT; LED-0603
E$1, E$2: FIDUCIAL1X2; FIDUCIAL-1X2
FRAME1: FRAME-LETTER; CREATIVE_COMMONS
JP1: M03PTH; 1X03
JP2, JP3: M04PTH; 1X04
LOGO1: SFE_LOGO_NAME_FLAME.2_INCH; SFE_LOGO_NAME_FLAME_.2
LOGO2: OSHW-LOGOS; OSHW-LOGO-S
R1, R2, R3, R4: 180; 0603-RES
R5, R6, R7, R8, R9: 10K; 0603-RES
S1: SWITCH-MOMENTARY-2SMD-2; TACTILE_SWITCH_SMD-2
U1, U2, U3, U4: HALL-EFFECTSMD; SC70
U$1, U$8, U$11, U$14: STAND-OFF
U$3: TRACKBALLMECH; TRACKBALL

Connections:
/BLU: JP2.1, R4.1
/BTN: JP1.3, R5.2, S1.1 (2)
/DWN: JP3.2, R7.2, U2.5 (OUT)
/GRN: JP2.3, R2.1
/LFT: JP3.3, R8.2, U3.5 (OUT)
/RED: JP2.2, R3.1
/RHT: JP3.4, R9.2, U4.5 (OUT)
/UP: JP3.1, R6.2, U1.5 (OUT)
/WHT: JP2.4, R1.1
GND: C1.2, C2.2, C3.2, C4.2, D1.C, D2.C, D3.C, D4.C, JP1.2, S1.2 (1), U1.2 (GND), U2.2 (GND), U3.2 (GND), U4.2 (GND)
unnamed: D1.A, R4.2
unnamed: D2.A, R3.2
unnamed: D3.A, R2.2
unnamed: D4.A, R1.2
VCC: C1.1, C2.1, C3.1, C4.1, JP1.1, R5.1, R6.1, R7.1, R8.1, R9.1, U1.4 (VCC), U2.4 (VCC), U3.4 (VCC), U4.4 (VCC)

Notes on the sheet:
v13
Nathan Seidle
Revised by: Patrick Alberts
VCC Range: 2.5V - 5.25V

Board: 2 copper layers, 27.9 x 24.1 mm, 35 parts (0 on the bottom side), 15 nets.

## Code that names these connections

File hardware/stm32-trackball-2U/stm32_dev.ioc (part):

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Mcu.Name=STM32F042G(4-6)Ux
Mcu.Package=UFQFPN28
Mcu.UserName=STM32F042G6Ux
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=nLED_RED
PA0.Signal=S_TIM2_CH1_ETR
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=nLED_GRN
PA1.Signal=S_TIM2_CH2
PA11.Mode=Device
PA11.Signal=USB_DM
PA12.Mode=Device
PA12.Signal=USB_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_SWCLK
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=nLED_BLU
PA2.Signal=S_TIM2_CH3
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=nLED_WHT
PA3.Signal=S_TIM2_CH4
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=TB_LEFT
PA4.Signal=GPIO_Input
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=TB_RIGHT
PA5.Signal=GPIO_Input
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=TB_UP
PA6.Signal=GPIO_Input
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=TB_DOWN
PA7.Signal=GPIO_Input
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=TB_BUTTON
PB0.Signal=GPIO_Input
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=USR_LED
PB1.Signal=GPIO_Output
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
RCC.SYSCLKFreq_VALUE=48000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_HSI48
board=custom

File software/atmega328/src/main.rs (part):

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use rtt_target::{rprintln, rtt_init_print};

use stm32f0xx_hal::{
    gpio::gpioa::{PA0, PA1, PA15, PA2, PA3, PA4, PA5, PA6, PA7},
    gpio::gpiob::{PB1, PB3, PB4},
    gpio::{Input, Output, PullUp, PushPull},
    pac,
    prelude::*,
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        usb_device: UsbDevice<'static, usb::UsbBusType>,
        usb_hid: HIDClass<'static, usb::UsbBusType>,
        exti: pac::EXTI,
        usr_led: PB1<Output<PushPull>>,
        button_right: PA15<Input<PullUp>>,
        button_left: PB4<Input<PullUp>>,
        button5: PB3<Input<PullUp>>,
        tb_left: PA4<Input<PullUp>>,
        tb_up: PA5<Input<PullUp>>,
        tb_right: PA6<Input<PullUp>>,
        tb_down: PA7<Input<PullUp>>,
        bbled_red: PA0<Output<PushPull>>,
        bbled_grn: PA1<Output<PushPull>>,
        bbled_blu: PA2<Output<PushPull>>,
        bbled_wht: PA3<Output<PushPull>>,
    }

    #[init]
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        // Alias peripherals
        let mut dp: pac::Peripherals = ctx.device;

        // This code enables clock for SYSCFG and remaps USB pins to PA9 and PA10.
        usb::remap_pins(&mut dp.RCC, &mut dp.SYSCFG);

        // TODO: Power on bbled dance (light up LEDs in a fun pattern when powered on)
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        let gpiob = dp.GPIOB.split(&mut rcc);
        let (usr_led, button_left, button5) = disable_interrupts(|cs| {
            (
                gpiob.pb1.into_push_pull_output(cs),
                gpiob.pb4.into_pull_up_input(cs),
                gpiob.pb3.into_pull_up_input(cs),
            )
        });

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            usb_dp,
        ) = disable_interrupts(|cs| {
            (
                gpioa.pa0.into_push_pull_output(cs),
                gpioa.pa1.into_push_pull_output(cs),
                gpioa.pa2.into_push_pull_output(cs),
                gpioa.pa3.into_push_pull_output(cs),
                gpioa.pa4.into_pull_up_input(cs),
                gpioa.pa5.into_pull_up_input(cs),
                gpioa.pa6.into_pull_up_input(cs),
                gpioa.pa7.into_pull_up_input(cs),
                gpioa.pa15.into_pull_up_input(cs),
                gpioa.pa11,
                gpioa.pa12,
            )
        });

        // Enable external interrupt for 3 aux buttons...
        dp.SYSCFG.exticr1.write(|w| w.exti3().pb3());
        // dp.SYSCFG.exticr2.write(|w| { w.exti4().pb4() }); // Disable spare button in favor of tb_left
        dp.SYSCFG.exticr4.write(|w| w.exti15().pa15());
        //... and for pulses on trackball
        dp.SYSCFG.exticr2.write(|w| w.exti4().pa4());
        dp.SYSCFG.exticr2.write(|w| w.exti5().pa5());
        dp.SYSCFG.exticr2.write(|w| w.exti6().pa6());
        dp.SYSCFG.exticr2.write(|w| w.exti7().pa7());

        // Set interrupt mask for all the above
        dp.EXTI.imr.write(|w| {
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
    #[task(binds = EXTI4_15, resources = [exti, usb_device, usb_hid, usr_led, bbled_red, bbled_grn, bbled_wht, bbled_blu])]
    fn exti_4_15_interrupt(ctx: exti_4_15_interrupt::Context) {
        rprintln!("Interrupts happening on EXTI for PA15...");

        let hid = ctx.resources.usb_hid;
        let usr_led = ctx.resources.usr_led;
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
## Commit log

2020-06-25 Add minimal explanation and kicad automation
2020-06-25 Correct markdown link
2020-06-25 add kicad gitignore
2020-06-25 add josh kicad lib
2020-06-25 add sparkfun breakout design files
2020-06-25 inital schematic +footprint import
2020-06-25 add button datasheet
2020-06-26 Restrict sch to kicad-only schematics, otherwise their clash with the Eagle ones
2020-06-26 Bump to kicad-exports 1.0, use full bom instead of just ibom, explicit schematic and boards files
2020-06-26 Indicate full path although we need board layout for correct bom generation, discard .DS_Store trash
2020-06-27 Rough board layout (without routing yet), arrange components, add fiducials, pours, etc...
2020-06-27 Versions shall never appear on filenames nor folders, that's what version control is for :D
2020-06-27 Change CI accordingly :)
2020-06-27 Use kicad-exports full potential
2020-06-27 Too early to have a functioning ERC, so sticking with DRC for now
2020-06-27 Unconnected tracks considered errors... FINE :P
2020-06-27 Everybody gets schematic and board now...
2020-06-27 partial layout, trackball TODO
2020-06-28 fix trackball led / hall position
2020-06-28 test
2020-06-28 attempting to fix broken symbol
2020-06-28 update jkl
2020-06-28 move symbol to updated kicad lib
2020-06-28 Trackball breakout mounting holes and almost-finished routing
2020-06-30 Flipped TB_UP and TB_RIGHT for more convenient routing on the trackball. Almost finished routing, pad-on-pad issues with the Switch and Trackball footprints prevent routing GNDs
2020-06-30 Removed S1 in favour of SW3, first pass (naive) routing finished
2020-06-30 Rename duplicate REF** names, they mess up with DSN export and pick and place machines
2020-06-30 add mounting holes to schematic, improve decoupling cap placement
2020-07-02 added extra buttons
2020-07-02 2u layout somehow passes DRC
2020-07-03 add silk
2020-07-05 ready to order
2020-07-05 change folder name
2020-07-05 off to fab
2020-07-05 can't find the files with conflict?
2020-07-05 Active wait for the pulses on GPIOs, lighting LEDs as they get triggered
2020-07-05 Mention what's left to do
2020-07-26 Add preliminary skeleton for STM32F04G6G IC from https://github.com/stm32-rs/stm32-usbd-examples/blob/master/example-stm32f042k6/src/main.rs and https://github.com/agalakhov/usbd-hid-device-example/b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
2020-07-26 No need for extra build step
2020-07-26 First successful flash with cargo embed :)
2020-08-02 Define buttons, led, usb peripheral, add USB HID report struct... meanwhile, it blinks ;)
2020-08-04 Correctly define the rest of I/O, next up: interrupts and hall sensors
2020-08-09 Migrated to RTIC thanks to https://gitlab.com/TheZoq2/hotas/-/tree/master as a reference. Does not USB-enumerate yet, working on it...
2020-08-09 Add USB interrupt mechanism and idle loop
2020-08-18 USB device was not enumerating, the only thing that was preventing it from working was the PA9/10/11/12 remapping. Also added RTT debugging and more hints and tips from @mvirkkunen and other really h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
2020-08-20 Remove most of the bloat, HID can be implemented with leaner crate. Introduce RTT based debugging via probe-rs on the STLinkv2, focusing on external interrupts now.
2020-08-22 Great feedback from RTIC matrix.org channel, still needs some more work handling interrupts, the stm32f0xx_hal is mature but has some quirks compared to other more modern HALs (i.e not having helper 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
2020-08-24 PA15 enters in the interrupt code but fails to clear the interrupt
2020-08-24 PA15 button interrupts working as expected, finally
2020-08-26 Try to introduce https://github.com/knurling-rs/defmt, not sure it works for this IC though :/
2020-08-26 Interrupt working for PA15 but failing to be cleared for the rest :-?
2020-08-27 Add proper cargo/rust-analyzer scan settings for vscode, solves https://github.com/rust-analyzer/rust-analyzer/issues/3801#issuecomment-681923193 for me
2020-08-29 Use write instead of modify for the interrupt setup and masking. Try to figure out why PA15 triggers fine but PB3 and PB4 get stuck into the interrupt task code (failing to clear the interrupt bit no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
2020-08-30 Just know your bits and the right ones you should be really be clearing for the interrupts. Cleanup as well
2020-08-30 All trackball interrupts working, we should disambiguate PB4 and PA4 somehow... perhaps switch to polling for those two? :-S
2020-08-30 Adding falling edge interrupts for conflicted interrupt lines
2020-08-30 Overlapping interrupt definitions result in newest taking priority
2020-09-03 How does one send USB interrupts w/ HID reports after an USB interrupt has been triggered?
2020-09-06 usb_dev polling on the USB interrupt and passing the mouse report to the polling does not seem to cut it :/
2020-09-06 Build, change device class to 0xFE as seen in https://github.com/jamesmunns/OtterPill-rs/blob/master/hello-mouse/src/main.rs
2020-09-06 More cleanup
2020-09-06 Cleanup, EXTI not working now??
2020-09-06 nops vs wfis... to recover RTT?
2020-09-06 Define idle loop resources even if they are not used?
2020-09-06 Minor use/import compact refactor
2020-09-06 Do not declare exti twice...
2020-09-12 Apparently order matters. If I init usb_hid **before** usb_dev, all interrupts work, the opposite freezes the program right after defining usb_hid :-S
2020-09-12 Clear up pending interrupts on the loop(), cleanup unnecessary cargo.toml feature definitions
2020-09-12 More rprintn statements to follow the program flow more closely. Cheekely change the VID:PID to my (working) Aliexpress USB mouse... doesn't matter though, no effect. Not using wfi triggers some sort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
2020-09-13 Refactor send_mouse_reports into a function... lets face the borrow checker now :_/
2020-09-13 Fighting generics with RTIC's Exclusive() and Mutex()
2020-09-14 Exclusive(), a.k.a Generics are tricky in RTIC: https://rtic.rs/0.5/book/en/by-example/tips.html#generics
2020-09-14 Aha, explicit priorities were messing up with generics...
2020-09-14 Adding the generics thing in the idle loop remains elusive :/
2020-09-14 Leds lighting on mouse report sending, adding usb_dev polling and report sending on the idle loop too as suggested by RTIC Lumpio
2020-09-14 unused manifest key: build
2020-09-21 The general idea is to poll() only in the interrupt handler, and after that attempt to read data (in your case you never read so no need to), thanks @mvirkkunen
2020-09-22 Mouse reports are relative, so passing 0 did obviously nothing with the mouse cursor :facepalm:... thanks @thalesfragoso
2020-09-24 Finally works on OSX :D... it was the VID:PID, never define an Apple product when it is not ;)
2020-09-24 Clean up unnecessary mouse report, add proper coordinates per axis
2020-09-25 Invert left/right, double range, class is not MISC but... autodetected via MouseReports I guess?
2020-09-27 Remove Sparkfun trackballer
2020-09-27 Highlight that this is Rust, folks ;)
2020-09-27 Rename datasheet folder
2020-09-27 Add proper context and links to the readme
2020-09-27 Mention PB4 (or was it PB3?) interrupt sharing issue
2020-09-27 Add dev board image
2020-09-27 Millenial emoji thing...
2020-09-27 Millenial emoji thing, take 2
2020-09-27 No need to even mention what a nightmare HID is :P
2020-09-27 s/board/PCB/
2020-09-27 Wrong datasheet, mate ;)
2020-09-27 kicad-exports v1 seems to be passé, moving on to 2.0...
2020-09-27 Karma returns to RTIC
2020-09-28 Add moonshot project that could come up as a result?
2020-09-28 Refine goals
2020-09-28 Link to RTIC chat
2020-09-28 I would love to work on that :D
2020-09-28 Add suggestions from rtic-examples pullrequest feedback
2020-09-28 Add back the stm32 2U form factor /cc @joshajohnson
2020-09-28 Arguments for kicad-exports seem to have been changed in 2.0
2020-09-29 Remap USB pins on the STM32F042 the easy way...
2020-09-29 Cleanup send mouse report func, only needs hid, not dev. Smooth (yet slower) mouse movements.
2020-10-03 basic mouse working
2020-10-03 working for real this time
2020-10-19 Add proper right/left button clicking/release thanks to Josh
2020-10-19 Thanks @joshajohnson for noticing a GNU/Linux only bug
2021-04-19 Add better looking photo for rust embedded showcase: http://showcase.rust-embedded.org/
2021-04-19 Not practical to develop this on an M1, will move to other machines for now (intel laptops)
2021-04-19 I .. just got:
    ```
    (...)
    Compiling target-cpu-fetch v0.1.3
    error: ran out of registers during register allocation
    error: aborting due to previous error
    ```
2021-04-19 Following advice from: https://book.avr-rust.com/003.1-the-avr-unknown-gnu-atmega328-target.html
2021-04-19 Remove cortex-m specific stuff
2023-10-29 Fast forward to KiCad 7 ;)

Notices in the files:
parts and their libraries:
https://creativecommons.org/licenses/by-sa/4.0
Released under the Creative Commons Attribution Share-Alike 4.0 License
